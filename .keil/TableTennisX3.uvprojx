# Keil uVision project TableTennisX3.uvprojx, settings and files
target Project (6140000::V6.14::ARMCLANG)
  device: NANO103SD3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: TableTennisX3 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=7 wLevel=3
  c include: ..\include;..\libraries\Official\CMSIS\Include;..\libraries\Official\Device\Nuvoton\Nano103\Include;..\libraries\Official\StdDriver\inc;..\libraries\User\inc;..\libraries\Driver\inc;..\libraries\Memory\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../libraries/Official/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../libraries/Official/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group Libraries_Official
    ../libraries/Official/StdDriver/src/: clk.c fmc.c gpio.c spi.c sys.c timer.c uart.c adc.c retarget.c rtc.c
  group Source
    ../Source/: main.c Application.c boot.c
  group Driver
    ../libraries/Driver/src/: Driver_MCU_SPI.c Driver_MPU9250.c Driver_Pressure.c Driver_ADC.c
  group Memory
    ../libraries/Memory/src/: vMemAlloc.c
